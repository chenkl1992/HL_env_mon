# IAR project envMonApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\SOA\CMSIS\Include; ..\SOA\CMSIS\Device\ST\STM32F1xx\Include; ..\SOA\STM32F1xx_HAL_Driver\Inc; ..\SOA\USER\app; ..\SOA\OS\cfg; ..\SOA\OS\src\uC-Clk\Source; ..\SOA\OS\src\uC-CPU; ..\SOA\OS\src\uC-CPU\ARM-Cortex-M\ARMv7-M\IAR; ..\SOA\OS\src\uC-LIB; ..\SOA\OS\src\uCOS-III\Source; ..\SOA\OS\src\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\SOA\BSP; ..\SOA\USER\modules\lwip-2.1.2\include; ..\SOA\USER\modules\lwip-2.1.2\include\lwip; ..\SOA\USER\modules\lwip-2.1.2\ports; ..\SOA\USER\drivers\delay; ..\SOA\USER\drivers\dm9000; ..\SOA\USER\drivers\debug; ..\SOA\USER\services\net_service; ..\SOA\USER\modules\hl_msg; ..\SOA\USER\modules\hl_packet; ..\SOA\USER\drivers\do; ..\SOA\USER\drivers\softi2c; ..\SOA\USER\drivers\rx8010; ..\SOA\USER\drivers\motor; ..\SOA\USER\services\data_service; ..\SOA\USER\services\motor_service; ..\SOA\USER\modules\sds; ..\SOA\USER\drivers\sflash; ..\SOA\USER\drivers\sflash\sds; ..\SOA\USER\services\update_service; ..\SOA\USER\modules\crc; ..\SOA\USER\services\report_service; ..\SOA\USER\services\tcp_service; ..\SOA\USER\services\udp_service; ..\SOA\USER\services\register_service; ..\SOA\USER\services\DA_service; ..\SOA\USER\services\cmd_service; ..\SOA\USER\services\event_service; ..\SOA\USER\services\heartbeat_service; ..\SOA\USER\services\shell_service; ..\SOA\USER\services\supervision_service; ..\SOA\USER\shell; ..\SOA\USER\log
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$r.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\SOA\CMSIS\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../SOA/BSP/: bsp_clk.c bsp_cpu.c bsp_led.c bsp_os.c
  group CMSIS
    ../SOA/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    ../SOA/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group LIB/Src
    ../SOA/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group OS/cfg
    ../SOA/OS/cfg/: app_cfg.h clk_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
  group OS/src/uC-Clk
    ../SOA/OS/src/uC-Clk/Source/: clk.c
    ../SOA/OS/src/uC-Clk/OS/uCOS-III/: clk_os.c
  group OS/src/uC-CPU
    ../SOA/OS/src/uC-CPU/ARM-Cortex-M/ARMv7-M/IAR/: cpu_a.asm
    ../SOA/OS/src/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../SOA/OS/src/uC-CPU/: cpu_core.c
  group OS/src/uC-LIB
    ../SOA/OS/src/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group OS/src/uCOS-III/Port
    ../SOA/OS/src/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu_a.asm
    ../SOA/OS/src/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group OS/src/uCOS-III/Src
    ../SOA/OS/src/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group USER/app
    ../SOA/USER/app/: BitBand.h main.c os_app_hooks.c stm32f1xx_hal_conf.h
  group USER/drivers/debug
    ../SOA/USER/drivers/debug/: debug.c debug.h printf-stdarg.c printf-stdarg.h
  group USER/drivers/delay
    ../SOA/USER/drivers/delay/: delay.c delay.h
  group USER/drivers/dm9000
    ../SOA/USER/drivers/dm9000/: dm9000.c dm9000.h
  group USER/drivers/sflash
    ../SOA/USER/drivers/sflash/: sFlash.c sFlash.h sFlash_cfg.h sFlash_port.c sFlash_port.h
  group USER/drivers/sflash/SDS
    ../SOA/USER/drivers/sflash/sds/: sds.c sds.h sds_cfg.h sds_port.c sds_port.h sds_table.c
  group USER/log
    ../SOA/USER/log/: log.c log.h
  group USER/modules/crc
    ../SOA/USER/modules/crc/: CRC.h CRC16_IBM.c CRC32_IEEE.c CRC8_CCITT.c CRC8_PLC.c
  group USER/modules/format
    ../SOA/USER/modules/crc/: format.c format.h
  group USER/modules/hl_msg
    ../SOA/USER/modules/hl_msg/: hl_malloc.c hl_malloc.h hl_msgdeal.c hl_msgdeal.h
  group USER/modules/hl_packet
    ../SOA/USER/modules/hl_packet/: hl_packet.c hl_packet.h
  group USER/modules/lwip/api
    ../SOA/USER/modules/lwip-2.1.2/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group USER/modules/lwip/core
    ../SOA/USER/modules/lwip-2.1.2/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group USER/modules/lwip/core/ipv4
    ../SOA/USER/modules/lwip-2.1.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group USER/modules/lwip/core/ipv6
    ../SOA/USER/modules/lwip-2.1.2/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group USER/modules/lwip/netif
    ../SOA/USER/modules/lwip-2.1.2/netif/: ethernet.c
  group USER/modules/lwip/ports
    ../SOA/USER/modules/lwip-2.1.2/ports/: ethernetif.c ethernetif.h lwip.c lwip.h lwipopts.h sys_arch.c
  group USER/modules/lwip/ports/arch
    ../SOA/USER/modules/lwip-2.1.2/ports/arch/: bpstruct.h cc.h cpu.h epstruct.h perf.h sys_arch.h
  group USER/services/DA
    ../SOA/USER/services/DA_service/: DA_service.c DA_service.h
  group USER/services/data
    ../SOA/USER/services/data_service/: data_service.c data_service.h
  group USER/services/event
    ../SOA/USER/services/event_service/: event_service.c event_service.h
  group USER/services/heartbeat
    ../SOA/USER/services/heartbeat_service/: heartbeat_service.c heartbeat_service.h
  group USER/services/net
    ../SOA/USER/services/net_service/: net_service.c net_service.h
  group USER/services/register
    ../SOA/USER/services/register_service/: register_service.c register_service.h
  group USER/services/shell
    ../SOA/USER/services/shell_service/: service_shell.c service_shell.h
  group USER/services/supervision
    ../SOA/USER/services/supervision_service/: supervision_service.c supervision_service.h
  group USER/services/TCP
    ../SOA/USER/services/tcp_service/: tcp_service.c tcp_service.h
  group USER/services/UDP
    ../SOA/USER/services/udp_service/: udp_service.c udp_service.h
  group USER/services/update
    ../SOA/USER/services/update_service/: update_service.c update_service.h
  group USER/shell
    ../SOA/USER/shell/: cmd_api_msg.c cmd_api_msg.h com_shell.c com_shell.h queue.c queue.h shell.c shell.h shell_call.c shell_call.h
