# IAR project SOA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\SOA\CMSIS\Include; ..\SOA\CMSIS\Device\ST\STM32F1xx\Include; ..\SOA\STM32F1xx_HAL_Driver\Inc; ..\SOA\USER\app; ..\SOA\BSP; ..\SOA\USER\drivers\debug; ..\SOA\USER\modules\hl_msg; ..\SOA\USER\modules\hl_packet; ..\SOA\USER\modules\sds; ..\SOA\USER\drivers\sflash; ..\SOA\USER\drivers\sflash\sds; ..\SOA\USER\modules\crc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SOA.bin
  ILINK.IlinkOutputFile: SOA.hex
  ILINK.IlinkIcfFile: ..\SOA\CMSIS\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../SOA/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    ../SOA/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group LIB/Src
    ../SOA/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group USER/app
    ../SOA/USER/app/: BitBand.h main.c stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h
  group USER/drivers/debug
    ../SOA/USER/drivers/debug/: printf-stdarg.c printf-stdarg.h
  group USER/drivers/sflash
    ../SOA/USER/drivers/sflash/: sFlash.c sFlash.h sFlash_cfg.h sFlash_port.c sFlash_port.h
  group USER/drivers/sflash/SDS
    ../SOA/USER/drivers/sflash/sds/: sds.c sds.h sds_cfg.h sds_port.c sds_port.h sds_table.c sds_table.h
  group USER/modules/crc
    ../SOA/USER/modules/crc/: CRC.h CRC16_IBM.c CRC32_IEEE.c CRC8_CCITT.c CRC8_PLC.c
  group USER/modules/hl_packet
    ../SOA/USER/modules/hl_packet/: hl_packet.c hl_packet.h
